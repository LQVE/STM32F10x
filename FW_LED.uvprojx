# Keil uVision project FW_LED.uvprojx, settings and files
target Target1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FW_LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Libraries\CMSIS;.\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User\led;.\User\key;.\User\rcc;.\User\exti;.\User\systick;.\User\usart;.\User\dma
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./User/: main.c stm32f10x_it.c
    ./User/led/: bsp_led.c
    ./User/key/: bsp_key.c
    ./User/rcc/: bsp_rccclkconfig.c
    ./User/exti/: bsp_exti.c
    ./User/systick/: bsp_systick.c
    ./User/dma/: bsp_dma_mtm.c bsp_dma_mtp.c
  group DOC
    ./Doc/: readme.txt
